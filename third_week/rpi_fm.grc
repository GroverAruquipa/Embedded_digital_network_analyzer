options:
  parameters:
    author: grover
    generate_options: no_gui
    id: rpi_fm
    output_language: python
    title: rpi_fm
  states: {}

blocks:
- name: f
  id: variable
  parameters:
    value: 86.8e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 230e3
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '3.14'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.4'
    comment: because a signa 0 and 1 0.4 and 0.5
    freq: '5000'
    offset: '0.5'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {state: disabled}
- name: rpitx_rpitx_sink_0
  id: rpitx_rpitx_sink
  parameters:
    carrier_freq: f
    samp_rate: samp_rate
  states: {}
- name: server_epy
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nimport socket\nimport string\nimport sys\n\n\n\ndef jmf_server(tt):\n## pi=pigpio.pi()\n## for gpioin in (21,20,26,16,19,13,5,6):\n##     pi.set_mode(g, gpio.OUTPUT)\n##     pi.write(g, 0)\n    while True:\n        sock=socket.socket(socket.AF_INET, socket.SOCK_STREAM)\n        sock.setsockopt(socket.SOL_SOCKET, socket.SO_REUSEADDR, 1)\n        sock.bind(('192.168.2.2', 4242))\n        print('Waitning for connection')\n        sock.listen(1)\n        conn, addr = sock.accept()\n        with conn:\n            print('Connected by', addr)\n            while True:\n                data = conn.recv(1)\n                if data:\n                    data=data.decode()\n                    print(data)\n                    if '*' in data:\n                        tt.f=tt.f+10000 # Frequency increment when receiving '*'\n                        tt.set_f(tt.f)\n                        print(\"f:\"+str(tt.f))\n                    if '+' in data:\n                        tt.f=tt.f-10000 ## FREQUENCY increment when receiving '+'\n                        tt.set_f(tt.f)\n                        print(\"f:\"+str(tt.f))\n                    if 'q' in data:\n                        print('bye')\n                        sock.shutdown(socket.SHUT_RDWR)\n                        sock.close()\n                        break\n\n"
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      print("Starting server" );
      import threading
      threading.Thread(target=server_epy.jmf_server, args=(self,)).start()
    section: main_after_init
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_const_source_x_0, '0', blocks_magphase_to_complex_0, '0']
- [analog_noise_source_x_0, '0', blocks_float_to_complex_0, '0']
- [analog_noise_source_x_0, '0', blocks_magphase_to_complex_0, '1']
- [analog_sig_source_x_0, '0', blocks_float_to_complex_0, '0']
- [analog_sig_source_x_0, '0', rpitx_rpitx_sink_0, '0']
- [blocks_float_to_complex_0, '0', rpitx_rpitx_sink_0, '0']
- [blocks_magphase_to_complex_0, '0', rpitx_rpitx_sink_0, '0']

metadata:
  file_format: 1
