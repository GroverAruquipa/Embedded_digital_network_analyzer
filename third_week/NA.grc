options:
  parameters:
    author: grover
    generate_options: no_gui
    id: NA
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 434e6
    gain0: '45'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://192.168.2.2:5555
    timeout: '100'
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
