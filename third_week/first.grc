options:
  parameters:
    author: grover
    generate_options: no_gui
    id: first
    output_language: python
    run: 'False'
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1152000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: '192000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '96000'
    decim: '6'
    gain: '1'
    samp_rate: '1152000'
    type: fir_filter_ccf
    width: '36000'
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 86e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: '1152'
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_wfm_rcv_0, '0', zeromq_pub_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
