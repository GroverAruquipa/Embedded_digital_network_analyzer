options:
  parameters:
    author: grover
    generate_options: qt_gui
    id: second12
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: f
  id: variable
  parameters:
    value: '2400000000'
  states: {}
- name: flo
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nimport socket\nimport string\nimport sys\n\n\n\ndef jmf_server(tt):\n## pi=pigpio.pi()\n## for gpioin in (21,20,26,16,19,13,5,6):\n##     pi.set_mode(g, gpio.OUTPUT)\n##     pi.write(g, 0)\n    while True:\n        sock=socket.socket(socket.AF_INET, socket.SOCK_STREAM)\n        sock.setsockopt(socket.SOL_SOCKET, socket.SO_REUSEADDR, 1)\n        sock.bind(('127.0.0.1', 4242))\n        print('Waitning for connection')\n        sock.listen(1)\n        conn, addr = sock.accept()\n        with conn:\n            print('Connected by', addr)\n            while True:\n                data = conn.recv(1)\n                if data:\n                    data=data.decode()\n                    print(data)\n                    if '*' in data:\n                        tt.flo=tt.flo+10000 # Frequency increment when receiving '*'\n                        tt.set_flo(tt.flo)\n                        print(\"flo\"+str(tt.flo))\n                    if '+' in data:\n                        tt.f=tt.f+10000 ## FREQUENCY increment when receiving '+'\n                        tt.set_f(tt.f)\n                        print(\"flo:\"+str(tt.flo))\n                    if 'q' in data:\n                        print('bye')\n                        sock.shutdown(socket.SHUT_RDWR)\n                        sock.close()\n                        break\n\n\n"
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 100e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      print("Starting server" );
      import threading
      threading.Thread(target=epy_module_0.jmf_server, args=(self,)).start()
    section: main_after_init
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://192.168.2.2:5555
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_stream_to_vector_0, '0', zeromq_pub_sink_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
