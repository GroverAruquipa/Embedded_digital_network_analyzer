options:
  parameters:
    author: grover
    generate_options: qt_gui
    id: script2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: f
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: flo
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nimport socket\nimport string\nimport sys\n\n\n\ndef jmf_server(tt):\n## pi=pigpio.pi()\n## for gpioin in (21,20,26,16,19,13,5,6):\n##     pi.set_mode(g, gpio.OUTPUT)\n##     pi.write(g, 0)\n    while True:\n        sock=socket.socket(socket.AF_INET, socket.SOCK_STREAM)\n        sock.setsockopt(socket.SOL_SOCKET, socket.SO_REUSEADDR, 1)\n        sock.bind(('127.0.0.1', 4242))\n        print('Waitning for connection')\n        sock.listen(1)\n        conn, addr = sock.accept()\n        with conn:\n            print('Connected by', addr)\n            while True:\n                data = conn.recv(1)\n                if data:\n                    data=data.decode()\n                    print(data)\n                    if '*' in data:\n                        tt.flo=tt.flo+10000 # Frequency increment when receiving '*'\n                        tt.set_flo(tt.flo)\n                        print(\"flo\"+str(tt.flo))\n                    if '+' in data:\n                        tt.f=tt.f+10000 ## FREQUENCY increment when receiving '+'\n                        tt.set_f(tt.f)\n                        print(\"flo:\"+str(tt.flo))\n                    if 'q' in data:\n                        print('bye')\n                        sock.shutdown(socket.SHUT_RDWR)\n                        sock.close()\n                        break\n\n\n"
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      print("Starting server" );
      import threading
      threading.Thread(target=epy_module_0.jmf_server, args=(self,)).start()
    section: main_after_init
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: '0'
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: '0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
    vlen: '2048'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [blocks_stream_to_vector_0, '0', zeromq_pub_sink_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
