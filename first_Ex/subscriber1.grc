options:
  parameters:
    author: grover
    generate_options: no_gui
    id: subscriber1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://192.168.2.2:5555
    timeout: '100'
    type: float
  states: {}

connections:
- [zeromq_sub_source_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
